# Keil uVision project Project.uvprojx, settings and files
target HY-RedBull V3.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\usart;..\USER\led;..\USER\can;..\USER\timer;..\USER\sys;..\USER\ttcan;..\USER\nodes;..\USER\speed;..\USER\sys\delay;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\TraceAnalyzer\include;..\TraceAnalyzer\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h
  group SysTick
    ../USER/SysTick/: stm32f10x_systick.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../: readme.txt
  group usart
    ../USER/usart/: usart.c usart.h
  group led
    ../USER/led/: led.c led.h
  group can
    ../USER/can/: can_config.c can_config.h
  group timer
    ../USER/timer/: timer.c timer.h
  group sys
    ../USER/sys/: sys.c sys.h
  group ttcan
    ../USER/ttcan/: ttcan.c ttcan.h TTCAN_mes.c TTCAN_mes.h
  group nodes
    ../USER/nodes/: nodes.c nodes.h
  group speed
    ../USER/speed/: Speed.h Speed.c
  group delay
    ../USER/sys/delay/: delay.c
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Tracealyzer
    ../TraceAnalyzer/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c trcStreamPort.c
